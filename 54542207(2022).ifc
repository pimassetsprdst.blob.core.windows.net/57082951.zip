Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-18T13:27:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 18 13:27:51 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{6AE1CD6D-16E7-41E9-8E0E-51E0A1B6266F}\ifc * Database version: 5507 * Database creation date: Wed May 18 13:27:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 18 13:27:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 18 13:27:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 54542207 Washbasin faucet, 54542207(2022):54542207 Washbasin faucet:462769
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 196.095 mm; NominalHeight: 239.4 mm; NominalWidth: 98.9063 mm
Type - General - Author: BIMStone; BIMObjectName: 54542207(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/05/2022
Type - Green Building Properties - EAN Number: 4057304017469; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.hansa.com/DoC/54542207; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/54542207; Catalog Drawing URL: http://static.hansa.com/catdrw/54542207; Dimension Drawing URL: http://static.hansa.com/dimdrw/54542207; FDV Document URL: http://www.hansa.com/datasheet/54542207/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/54542207; Group: Washbasin faucet; Interactive AR View URL: https://static.hansa.com/AR/54542207; Item Type: Sales item; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;France;Czech Republic;Slovakia;Italy;Spain; Mobile Product Information URL: http://mpi.hansa.com/54542207; Model: 54542207 Washbasin faucet; Name_en: 54542207 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 54542207; Product Family: HANSAVANTIS Style; Product Image URL: http://static.hansa.com/image/54542207; Product URL: http://static.hansa.com/54542207; Technical DataSheet URL: http://www.hansa.com/datasheet/54542207/en; Type Name: 54542207 Washbasin faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Pop-up waste with draw-rod; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 147 mm; Spout Swivel Range: 120°; Spout Type: Swivel spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 54542207(2022); Features: Single-lever, side operated; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 54542207; Name: 54542207 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 100x195x240 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 54542207; Manufacturer: HANSA
Pset_DistributionFlowElementCommon - Reference: 54542207 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0911178 m2; Volume: 0.00464788 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 54542207(2022): 54542207 Washbasin faucet; Family and Type: 54542207(2022): 54542207 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 54542207(2022): 54542207 Washbasin faucet; Type Id: 54542207(2022): 54542207 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
